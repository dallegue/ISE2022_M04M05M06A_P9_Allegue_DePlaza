# Keil uVision project hito1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hito1
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c thread_i2c.c thread_i2c.h thread_medida.c thread_medida.h adc.c adc.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, CMSIS Driver:I2C 2.5.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
